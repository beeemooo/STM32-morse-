# Keil uVision project project.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c misc: -D__MICROLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Source Group 1
    ./: main.c startup_stm32l476xx.s stm32l476xx.h LED.c SysClock.c UART.c UART_printf.c README.md SysTimer.c SysTimer.h Char_to_Morse.c Char_to_Morse.h LED.h UART.h ring_buffer.c ring_buffer.h
software components: CMSIS:CORE 5.6.0
